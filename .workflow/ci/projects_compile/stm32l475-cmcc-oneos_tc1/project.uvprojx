# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx, USE_HAL_DRIVER
  c include: .;application;..\..\arch\arm\armv7m\include;..\..\components\atest\include;board;board\CubeMX_Config\Inc;board\ports;board\packages;..\..\components\ota\cmiot\inc;..\..\components\ringbuf\include;..\..\components\dlog\include;..\..\components\dlog\include\syslog;..\..\drivers;..\..\drivers\bus;..\..\drivers\console;..\..\drivers\fal;..\..\drivers\misc;..\..\drivers\pin;..\..\drivers\serial;..\..\drivers\timer;..\..\drivers\hal\st\devices;..\..\drivers\hal\st\drivers;..\..\drivers\hal\st\drivers\config;..\..\drivers\hal\st\drivers\drv_flash;..\..\drivers\hal\st\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;..\..\drivers\hal\st\STM32L4xx_HAL\CMSIS\Include;..\..\oneos-kernel\include;..\..\components\libc\include;..\..\components\libc\include\extension;..\..\components\libc\include\armlibc;..\..\components\molink\api\include;..\..\components\molink\core\include;..\..\components\molink\module\a7600x\include;..\..\components\molink\module\a7670x\include;..\..\components\molink\module\air720uh\include;..\..\components\molink\module\air723ug\include;..\..\components\molink\module\bc20\include;..\..\components\molink\module\bc26\include;..\..\components\molink\module\bc28\include;..\..\components\molink\module\bc95\include;..\..\components\molink\module\clm920rv3\include;..\..\components\molink\module\ec20\include;..\..\components\molink\module\ec200x_600s\include;..\..\components\molink\module\esp32\include;..\..\components\molink\module\esp8266\include;..\..\components\molink\module\gm120\include;..\..\components\molink\module\gm190\include;..\..\components\molink\module\gm510\include;..\..\components\molink\module\l610\include;..\..\components\molink\module\m5310a\include;..\..\components\molink\module\m5311\include;..\..\components\molink\module\me3616\include;..\..\components\molink\module\me3630_w\include;..\..\components\molink\module\ml302\include;..\..\components\molink\module\n21\include;..\..\components\molink\module\n58\include;..\..\components\molink\module\sim7020\include;..\..\components\molink\module\sim7070x\include;..\..\components\molink\module\sim7600ce\include;..\..\components\molink\parser\include;..\..\components\shell\include;..\..\components\socket\include;..\..\components\socket\include\sys_socket
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314
  group application
    application/: main.c
  group arch
    ../../arch/arm/armv7m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
    ../../arch/arm/armv7m/: arch_task.c arch_exception.c arch_interrupt.c arch_misc.c arch_atomic.c
  group atest
    ../../components/atest/source/: atest.c
  group bsp
    board/: board.c
    board/CubeMX_Config/Src/: bsp.c stm32l4xx_it_bsp.c stm32l4xx_hal_msp.c system_stm32l4xx.c
    board/startup/: startup_stm32l475xx_arm.s
  group cmiot
    ../../components/ota/cmiot/src/: cmiot_self.c cmiot_user.c
  group cmiotlib
    ../../components/ota/cmiot/lib/: arm_cortex-m4_cmiot_fota.lib
  group common
    ../../components/ringbuf/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: console_backend.c
    ../../components/dlog/source/syslog/: syslog.c
  group drivers
    ../../drivers/: driver.c device.c
    ../../drivers/bus/: bus.c
    ../../drivers/console/: console.c
    ../../drivers/fal/: fal.c fal_part.c
    ../../drivers/misc/: push_button.c
    ../../drivers/pin/: pin.c
    ../../drivers/serial/: serial.c
    ../../drivers/timer/: timer.c clocksource.c clockevent.c hrtimer.c clocksource_cortexm.c
  group hal/devices
    ../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_common.c
    ../../drivers/hal/st/drivers/flash/: drv_flash_l4.c
  group hal/lowlevel
    ../../drivers/hal/st/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_hcd.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_can.c stm32l4xx_hal_lptim.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c
  group kernel
    ../../oneos-kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_mem_small.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
  group libc
    ../../components/libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../components/libc/source/common/: gmtime_r.c
  group molink
    ../../components/molink/api/source/: mo_common.c mo_factory.c mo_general.c mo_netserv.c mo_ping.c mo_netconn.c mo_socket.c mo_onenet_nb.c mo_wifi.c
    ../../components/molink/core/source/: mo_object.c mo_lib.c mo_ipaddr.c mo_time.c
    ../../components/molink/module/a7600x/source/: a7600x.c a7600x_general.c a7600x_netserv.c a7600x_netconn.c
    ../../components/molink/module/a7670x/source/: a7670x.c a7670x_general.c a7670x_netserv.c a7670x_netconn.c
    ../../components/molink/module/air720uh/source/: air720uh.c air720uh_general.c air720uh_netserv.c air720uh_netconn.c
    ../../components/molink/module/air723ug/source/: air723ug.c air723ug_general.c air723ug_netserv.c air723ug_netconn.c
    ../../components/molink/module/bc20/source/: bc20.c bc20_general.c bc20_netserv.c bc20_netconn.c
    ../../components/molink/module/bc26/source/: bc26.c bc26_general.c bc26_netserv.c bc26_netconn.c
    ../../components/molink/module/bc28/source/: bc28.c bc28_general.c bc28_netserv.c bc28_netconn.c
    ../../components/molink/module/bc95/source/: bc95.c bc95_general.c bc95_netserv.c bc95_netconn.c
    ../../components/molink/module/clm920rv3/source/: clm920rv3.c clm920rv3_general.c clm920rv3_netserv.c clm920rv3_ping.c clm920rv3_netconn.c
    ../../components/molink/module/ec20/source/: ec20.c ec20_general.c ec20_netserv.c ec20_netconn.c
    ../../components/molink/module/ec200x_600s/source/: ec200x_600s.c ec200x_600s_general.c ec200x_600s_netserv.c ec200x_600s_netconn.c
    ../../components/molink/module/esp32/source/: esp32.c esp32_general.c esp32_wifi.c esp32_netconn.c
    ../../components/molink/module/esp8266/source/: esp8266.c esp8266_general.c esp8266_wifi.c esp8266_netconn.c
    ../../components/molink/module/gm120/source/: gm120.c gm120_general.c gm120_netserv.c gm120_netconn.c
    ../../components/molink/module/gm190/source/: gm190.c gm190_general.c gm190_netserv.c gm190_netconn.c
    ../../components/molink/module/gm510/source/: gm510.c gm510_general.c gm510_netserv.c gm510_netconn.c
    ../../components/molink/module/l610/source/: l610.c l610_general.c l610_netserv.c l610_netconn.c
    ../../components/molink/module/m5310a/source/: m5310a.c m5310a_general.c m5310a_netserv.c m5310a_netconn.c
    ../../components/molink/module/m5311/source/: m5311.c m5311_general.c m5311_netserv.c m5311_netconn.c m5311_onenet_nb.c
    ../../components/molink/module/me3616/source/: me3616.c me3616_general.c me3616_netserv.c me3616_netconn.c
    ../../components/molink/module/me3630_w/source/: me3630_w.c me3630_w_general.c me3630_w_netserv.c me3630_w_netconn.c
    ../../components/molink/module/ml302/source/: ml302.c ml302_general.c ml302_netserv.c ml302_netconn.c
    ../../components/molink/module/n21/source/: n21.c n21_general.c n21_netserv.c n21_netconn.c
    ../../components/molink/module/n58/source/: n58.c n58_general.c n58_netserv.c n58_netconn.c
    ../../components/molink/module/sim7020/source/: sim7020.c sim7020_general.c sim7020_netserv.c sim7020_netconn.c
    ../../components/molink/module/sim7070x/source/: sim7070x.c sim7070x_general.c sim7070x_netserv.c sim7070x_netconn.c
    ../../components/molink/module/sim7600ce/source/: sim7600ce.c sim7600ce_general.c sim7600ce_netserv.c sim7600ce_netconn.c
    ../../components/molink/parser/source/: at_parser.c at_resp.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
  group socket
    ../../components/socket/source/: socket.c
