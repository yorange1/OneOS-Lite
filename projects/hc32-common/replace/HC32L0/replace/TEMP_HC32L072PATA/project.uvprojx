# Keil uVision project project.uvprojx, settings and files
target oneos (ARM-ADS)
  device: HC32L072PATA HDSC
  pack: HDSC.HC32L07X.1.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: oneos
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HC32L07xPxxx, USE_HAL_DRIVER
  c include: .;application;..\..\arch\arm\armv6m\include;board;board\ports;..\..\drivers\hal\hdsc\common\HC32L07x;..\..\common\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\console;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\mtd;..\..\drivers\pin;..\..\drivers\serial;..\..\drivers\sn;..\..\drivers\hal\hdsc\CMSIS\Core\Include;..\..\drivers\hal\hdsc\drivers;..\..\drivers\hal\hdsc\HC32L07x_HAL\inc;..\..\kernel\include;..\..\libc\include;..\..\libc\include\extension;..\..\libc\include\armlibc;..\..\components\diagnose\resource_moniter;..\..\components\shell\include;..\..\components\diagnose\stack_trace
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*Handler --diag_suppress L6314W
  group application
    application/: main.c
  group arch
    ../../arch/arm/armv6m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
    ../../arch/arm/armv6m/: arch_task.c arch_exception.c arch_interrupt.c arch_misc.c arch_atomic.c
  group bsp
    board/: board.c
    board/startup/: startup_hc32l07x_arm.s
    ../../drivers/hal/hdsc/common/HC32L07x/: system_hc32l07x.c interrupts_hc32l07x.c
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: console_backend.c
  group drivers
    ../../drivers/: driver.c device.c
    ../../drivers/block/: block_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/console/: console.c
    ../../drivers/dma/: dma.c
    ../../drivers/fal/: fal.c fal_part.c fal_mtd.c fal_block.c
    ../../drivers/mtd/: mtd.c
    ../../drivers/pin/: pin.c
    ../../drivers/serial/: serial.c
    ../../drivers/sn/: sn_cfg.c
  group hal/drivers
    ../../drivers/hal/hdsc/drivers/: drv_common.c drv_gpio.c drv_usart_l1xx.c
    ../../drivers/hal/hdsc/drivers/flash/: drv_flash_l1xx.c
  group hal/lowlevel
    ../../drivers/hal/hdsc/HC32L07x_HAL/src/: hc_sysctrl.c hc_ddl.c hc_gpio.c hc_reset.c hc_uart.c hc_flash.c hc_dmac.c
  group kernel
    ../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../libc/source/common/: gmtime_r.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
