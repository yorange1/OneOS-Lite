# Keil uVision project project.uvprojx, settings and files
target oneos (6140000::V6.14::ARMCLANG)
  device: HC32L176PATA HDSC
  pack: HDSC.HC32L17X.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: oneos
  AfterMake: fromelf --bin !L --output oneos.bin
  AfterMake: ..\..\components\ota\cmiot\cmiot_bin.bat "C:\Program Files\7-Zip\7z.exe" oneos_config.h oneos.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HC32L17xPxxx, USE_HAL_DRIVER
  c include: .;application;..\..\arch\arm\armv6m\include;board;board\ports;..\..\drivers\hal\hdsc\HC32L17x_HAL\common;..\..\components\ota\cmiot\inc;..\..\components\ringbuf\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\console;..\..\drivers\fal;..\..\drivers\misc;..\..\drivers\pin;..\..\drivers\serial;..\..\drivers\hal\hdsc\HC32L17x_HAL\CMSIS\Core\Include;..\..\drivers\hal\hdsc\devices;..\..\drivers\hal\hdsc\drivers;..\..\drivers\hal\hdsc\HC32L17x_HAL\hal_drivers\inc;..\..\kernel\include;..\..\components\libc\include;..\..\components\libc\include\extension;..\..\components\libc\include\armlibc;..\..\components\molink\api\include;..\..\components\molink\core\include;..\..\components\molink\module\m5311\include;..\..\components\molink\parser\include;..\..\components\shell\include;..\..\components\socket\include;..\..\components\socket\include\sys_socket
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*Handler --diag_suppress L6314W
  group application
    application/: main.c
  group arch
    ../../arch/arm/armv6m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
    ../../arch/arm/armv6m/: arch_task.c arch_exception.c arch_interrupt.c arch_misc.c arch_atomic.c
  group bsp
    board/: board.c
    board/startup/: startup_hc32l17x_arm.s
    ../../drivers/hal/hdsc/HC32L17x_HAL/common/: system_hc32l17x.c interrupts_hc32l17x.c
  group cmiot
    ../../components/ota/cmiot/src/: cmiot_self.c cmiot_user.c
  group cmiotlib
    ../../components/ota/cmiot/lib/: arm_cortex-m0_cmiot_fota.lib
  group common
    ../../components/ringbuf/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group drivers
    ../../drivers/: driver.c device.c
    ../../drivers/bus/: bus.c
    ../../drivers/console/: console.c
    ../../drivers/fal/: fal.c fal_part.c
    ../../drivers/misc/: push_button.c adc.c
    ../../drivers/serial/: serial.c
  group hal/devices
    ../../drivers/hal/hdsc/devices/: hc32_devices.c
  group hal/drivers
    ../../drivers/hal/hdsc/drivers/: drv_common.c drv_gpio.c drv_adc.c drv_usart.c
    ../../drivers/hal/hdsc/drivers/flash/: drv_flash.c
  group hal/lowlevel
    ../../drivers/hal/hdsc/HC32L17x_HAL/hal_drivers/src/: hc_sysctrl.c hc_ddl.c hc_gpio.c hc_reset.c hc_uart.c hc_flash.c hc_adc.c hc_bgr.c
  group kernel
    ../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_small.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
  group libc
    ../../components/libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../components/libc/source/common/: gmtime_r.c
  group molink
    ../../components/molink/api/source/: mo_common.c mo_factory.c mo_netconn.c mo_socket.c
    ../../components/molink/core/source/: mo_object.c mo_lib.c mo_ipaddr.c
    ../../components/molink/module/m5311/source/: m5311.c m5311_netconn.c
    ../../components/molink/parser/source/: at_parser.c at_resp.c at_printf.c
  group socket
    ../../components/socket/source/: socket.c
