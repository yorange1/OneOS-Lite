# Keil uVision project template.uvprojx, settings and files
target oneos (ARM-ADS)
  device: HC32L176PATA HDSC
  pack: HDSC.HC32L17X.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: oneos
  AfterMake: fromelf --bin !L --output oneos.bin
  AfterMake: ..\..\components\ota\cmiot\cmiot_bin.bat "C:\Program Files\7-Zip\7z.exe" oneos_config.h oneos.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*Handler --diag_suppress L6314W
