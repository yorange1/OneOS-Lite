# Keil uVision project project.uvprojx, settings and files
target oneos (6140000::V6.14::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER, STM32F103xE
  c include: .;application;..\..\arch\arm\armv7m\include;board;board\CubeMX_Config\Inc;board\ports;board\packages;..\..\components\ringbuf\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\console;..\..\drivers\misc;..\..\drivers\pin;..\..\drivers\serial;..\..\drivers\timer;..\..\drivers\hal\st\devices;..\..\drivers\hal\st\drivers;..\..\drivers\hal\st\drivers\config;..\..\drivers\hal\st\drivers\drv_flash;..\..\drivers\hal\st\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\..\drivers\hal\st\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32F1xx_HAL\CMSIS\Include;..\..\oneos-kernel\include;..\..\components\libc\include;..\..\components\libc\include\extension;..\..\components\libc\include\armlibc;..\..\components\shell\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314
  group application
    application/: main.c
  group arch
    ../../arch/arm/armv7m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
    ../../arch/arm/armv7m/: arch_task.c arch_exception.c arch_interrupt.c arch_misc.c arch_atomic.c
  group bsp
    board/: board.c
    board/CubeMX_Config/Src/: bsp.c stm32f1xx_it_bsp.c stm32f1xx_hal_msp.c system_stm32f1xx.c
    board/startup/: startup_stm32f103xe_arm.s
  group common
    ../../components/ringbuf/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group drivers
    ../../drivers/: driver.c device.c
    ../../drivers/bus/: bus.c
    ../../drivers/console/: console.c
    ../../drivers/misc/: push_button.c
    ../../drivers/pin/: pin.c
    ../../drivers/serial/: serial.c
    ../../drivers/timer/: timer.c clocksource.c clocksource_cortexm.c
  group hal/devices
    ../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_common.c
  group hal/lowlevel
    ../../drivers/hal/st/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group kernel
    ../../oneos-kernel/source/: os_block.c os_clock.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_small.c os_memory.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
  group libc
    ../../components/libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../components/libc/source/common/: gmtime_r.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
